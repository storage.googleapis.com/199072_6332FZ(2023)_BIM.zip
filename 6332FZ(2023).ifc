Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-10-21T20:06:33
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20191106_1200(x64) - Exporter 20.2.1.1 - Alternate UI 20.2.1.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sat Oct 21 20:06:33 2023 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\00bcdd55-e729-4a74-9953-da3241b926e8\2ae840b0-1f93-4f7d-ba98-58800955e23f\ifc * Database version: 5507 * Database creation date: Sat Oct 21 20:06:31 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sat Oct 21 20:06:31 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sat Oct 21 20:06:31 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCE

# IfcFlowController: 6332FZ Washbasin faucet, 6 V, Bluetooth, 6332FZ(2023):6332FZ Washbasin faucet, 6 V, Bluetooth:436168
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - FaucetNominalDepth: 161.5 mm; FaucetNominalHeight: 292.5 mm; FaucetNominalWidth: 72 mm; HandShowerNominalDepth: 64.3 mm; HandShowerNominalHeight: 296.7 mm; HandShowerNominalWidth: 49.3 mm; InletConnectionSize: 10 mm
Type - Electrical - Battery: Lithium 2CR5 6 V; Bluetooth: 4.x (D034445); Operating Voltage: 6 V; Protection Class: IP 55
Type - General - Author: BIMStone; BIMObjectName: 6332FZ(2023); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: Washbasin faucet with Bidetta hand shower; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 01/06/2023
Type - Green Building Properties - CO2 Emissions (A1-A3): 13.3; CO2 Emissions (A4): 0.49; CO2 Emissions (B7): 430; CO2 Emissions (C2): 0.02; CO2 Emissions (C3): 0.03; CO2 Emissions (C4): 0.37; CO2 Emissions (D): -9.7; EAN Number: 6414150096518; EMC Directive: Radio Equipment Directive 2014/53/EU , Low Voltage Directive 2014/35/EU , EMC Directive 2014/30/EU , RoHS Directive 2011/65/EU; EN Standard: EN 15091, EN 1113, ETSI EN 301 489-1 V1.9.2 , ETSI EN 300 328 v2.2.2 , EN 61000-6-1:2007 , EN 61000-6-3:2007+A1:2011+AC:2012 , EN 60335-1:2012+A11+A13+A1+A14+A2+A15:2021, Part 19.11.4; ETIM Class Number: EC010340 Electronic tap; LVI Number: 6110320; Noise Class: I (ISO 3822); RSK Number: 8430613; Sales Package dimensions (LxWxH): 696 x 320 x 88; STF Certificate: EUFI29-21002459-TH1; UNSPSC Class Number: 30181700 Faucets or taps; URL Declaration of Asbestos: http://static.oras.com/doc/asbestos; URL Declaration of Conformity: http://static.oras.com/DoC/6332FZ; URL Declaration Of Performance (DOP): http://static.oras.com/doc/DoP; URL Declaration of SCIP: http://static.oras.com/doc/SCIP; URL EcoLabel Declaration: http://static.oras.com/doc/EcoLabel; URL Environmental Product Declaration EPD: http://www.oras.com/fileadmin/resources/166421_Oras_EPD_Electronic_washbasin_faucet_2022_06_29.pdf; URL EU Packaging Declaration: http://static.oras.com/doc/packaging; URL Materials Declaration: http://www.oras.com/fileadmin/resources/181249_6332FZ_materialsdeclaration.pdf; URL REACH: http://static.oras.com/doc/reach; URL STF: http://static.oras.com/STF/6332FZ; URL UN38.3: http://static.oras.com/UN383/6332FZ; URL WEEE: http://static.oras.com/WEEE/6332FZ; VVS Number: 704274234
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/6332FZ; 3D View: https://static.oras.com/AR/6332FZ; Catalog Drawing URL: http://static.oras.com/catdrw/6332FZ; Dimension Drawing URL: http://static.oras.com/dimdrw/6332FZ; FDV Document URL: http://www.oras.com/datasheet/6332FZ/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/6332FZ; Group: Washbasin faucet; Installation and Maintenance Guide URL: http://static.oras.com/manual/6332FZ; Interactive AR View URL: https://static.oras.com/AR/6332FZ; Manufacturer: Oras; Market: International;Finland;Sweden;Poland;Russia;Estonia;Lithuania;Latvia;Ukraine; Mobile Product Information URL: http://mpi.oras.com/6332FZ; Model: 6332FZ Washbasin faucet, 6 V, Bluetooth; Name_en: 6332FZ Washbasin faucet, 6 V, Bluetooth; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 6332FZ; Product Family: Oras Electra; Product Image URL: http://static.oras.com/image/6332FZ; Product URL: http://static.oras.com/6332FZ; Spare-Part Information URL: http://static.oras.com/sp/6332FZ; Technical DataSheet URL: http://www.oras.com/datasheet/6332FZ/en; Type Name: 6332FZ Washbasin faucet, 6 V, Bluetooth; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Advanced Features: Software settings adjustable via App; Aerator: Hidden aerator; Afterflow Period: 3 s (1-20 s); Automatic Flush Frequency: off (off/1-120 h); Automatic Flush Period: 30 s (1-1800 s); Backflow Prevention EN1717: HC; Connection: Flexible inlet pipes; Connection Size: G3/8; Electronic Parts: Autofocus infrared sensor;Solenoid valve;Low battery indicator; Flow Rate At 300kPa With Flow Controller: 0.000353147 m3/s; Hand Shower: Bidetta hand shower; Installation Type: Deck mounted; Lever Handle: Temperature control handle; Max. Hot Water Supply: 70 kg/K/s3; Max Flow Period: 2 min (1 - 1800 s); Mechanical Parts: Mixing valve for manual temperature control;Non-return valve(s);Litter filter(s); Mounting Holes: 1 hole; Operating Distance: 20-180 mm (150/180/250 mm); Pressure Loss With Flow 01ls: 200000 Pa; Shower Parts: Hand shower;Shower holder;Shower hose (1500 mm); Spout Projection: 120 mm; Spout Type: Fixed spout; Surface treatment: Chrome; Temperature: Temperature limiter (retrofittable); Temperature Adjustments: Adjustable hot water stop (included, retrofittable); Working Pressure: 100 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 6332FZ(2023); Features: Touchless;Bluetooth®;Battery-operated;Bidetta; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 6332FZ; Name: 6332FZ Washbasin faucet, 6 V, Bluetooth; ReplacementCost: n/a; Shape: Sculptured; Size: Faucet: 70x160x295 mm / Hand shower: 45x65x285 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ValveTypeCommon - ValvePattern: n/a; ValveOperation: n/a; ValveMechanism: n/a; FlowCoefficient: 0; CloseOffRating: 0 Pa
Type - Pset_ValveTypeFaucet - Finish: Polished
Pset_DistributionFlowElementCommon - Reference: 6332FZ Washbasin faucet, 6 V, Bluetooth; sets with these values: 2
Pset_ElementShading - Color: Chrome
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Pset_ManufacturerTypeInformation - ModelReference: 6332FZ; Manufacturer: Oras
Pset_ProductRequirements - Name: 6332FZ Washbasin faucet, 6 V, Bluetooth; Category: Plumbing Fixtures
Constraints - DistanceX-Axis: 150 mm; DistanceY-Axis: 150 mm; Elevation from Level: 0 mm; FaucetDefaultElevation: 900 mm; HandShowerDefaultElevation: 900 mm; Hand Shower Visibility: yes; Host: Level : Level 1; Level: Level: Level 1; Offset from Host: 0 mm
Dimensions - Area: 0.117896 m2; Volume: 0.00434612 m3
Identity Data - Mark: 28
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 6332FZ(2023): 6332FZ Washbasin faucet, 6 V, Bluetooth; Family and Type: 6332FZ(2023): 6332FZ Washbasin faucet, 6 V, Bluetooth; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 6332FZ(2023): 6332FZ Washbasin faucet, 6 V, Bluetooth; Type Id: 6332FZ(2023): 6332FZ Washbasin faucet, 6 V, Bluetooth; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
